Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 7f1c1e22-cd10-41c1-bc62-6b6964043bc3.ifc
Time: 2026-08-11T12:00:53
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, scharnierend Storax - BV-GD-F90 66, 600x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAOizehcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIA0-wCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOizehcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIA0-wCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 31 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 752 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 735 mm; Rc-waarde: 0 m²·k/w; brandwerendheid E: 120 min; serie: BV-GD-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 66; dagmaatbreedte: 600 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer

Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: c0bb6ebe-1811-4060-a6ff-631377641336.ifc
Time: 2026-08-11T12:03:43
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, scharnierend Storax - BV-GD-F90 86, 600x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAOg8fRcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIAXOsCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOg8fRcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIAXOsCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 38 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 752 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 935 mm; Rc-waarde: 0 m²·k/w; brandwerendheid E: 120 min; serie: BV-GD-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 86; dagmaatbreedte: 800 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer

Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0b93c132-2bf3-4d59-a2cc-850db0b3a5e1.ifc
Time: 2026-08-11T12:05:23
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, scharnierend Storax - BV-GD-F90 106, 600x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAOjEfRcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIApOsCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOjEfRcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIApOsCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 44 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 752 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 0 m²·k/w; brandwerendheid E: 120 min; serie: BV-GD-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 106; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer

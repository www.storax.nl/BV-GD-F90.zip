Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 57b1d5a7-d470-41ca-b706-b4aa5b8e8f98.ifc
Time: 2026-08-11T12:06:38
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, scharnierend Storax - BV-GD-F90 110, 1000x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAOiCfRcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIA4usCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOiCfRcFAAAAg-sCAAV2SgAAlV8BAInDAADZ7AIA4usCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 57 kg/st; STABU2: 43.31.10; dagmaatlengte: 1000 mm; lengte: 1152 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 0 m²·k/w; brandwerendheid E: 120 min; serie: BV-GD-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 110; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer
